# Repository takushio2525/R7FA8M1AHECFB_v1

## KiCad design R7FA8M1AHECFB_v1.kicad_pcb

Parts:
C101, C104, C105, C106, C107, C109, C110, C113, C115, C116, C117, C118, C120, C121: 0.1u; C_0603_1608Metric
C102, C108, C111, C114: 0.22u; C_0603_1608Metric
C103: 22u; C_1206_3216Metric
C112: 47u; C_1210_3225Metric
C119: 4.7u; C_0805_2012Metric
D101, D102, D103, D104, D105, D106, D107, D108: LED; LED_0603_1608Metric
D117: D; D_SMA
IC101: R7FA8M1AHECFB#AA0; QFP50P2200X2200X170-144N; Manufacturer_Part_Number R7FA8M1AHECFB#AA0; Mouser Part Number 968-R7FA8M1AHECFBAA0
J101, J107: Conn_01x04_Pin; B04BPASKLFSN
J102: Conn_01x10_Pin; CONN_3220-10-0100-00_CNC
J103: USB_C_Receptacle; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J104: Conn_01x05_Pin; B05BPASK1
J106: Conn_01x06_Pin; B06BPASK1LFSN
J109: 5051102296; Manufacturer_Part_Number 5051102296
J110: DM3AT-SF-PEJM5; HRS_DM3AT-SF-PEJM5; PARTREV 20200913
L101: 2.2u; IND_SPM5020T-4R7M-LR
LED101, LED102: APTF1616LSEEZGKQBKC; APTF1616SEEZGQBDC; Manufacturer_Part_Number APTF1616LSEEZGKQBKC; Mouser Part Number 604-APTF1616LSEEZGKQ
R101, R102, R103, R104, R105, R107, R109, R110, R122, R123: 330; R_0603_1608Metric
R106, R108, R121, R124, R131, R132, R133, R134, R135, R136, R137: 10k; R_0603_1608Metric
R119, R120, R128, R129: 150; R_0603_1608Metric
R125: 2.2k; R_0603_1608Metric
R126, R127: 5.1k; R_0603_1608Metric
RV101: R_Potentiometer; Potentiometer_Vishay_T73YP_Vertical
RV102: R_Potentiometer; B03BPASKLFSN
S101: KAE04LGGR; Manufacturer_Part_Number KAE04LGGR; Mouser Part Number 612-KAE04LGGR
SW102, SW103, SW105, SW106, SW108: SKRPADE010; SKRPADE010_AAL
SW107: SW_Nidec_CAS-120A1; SW_SLW-883935-2A-D
U101: AQM0802A-RN-GBW
Y101: KC2016Z20.0000C1KX00; OSC_KC2016Z20.0000C1KX00-4; PARTREV August 2021

Connections:
+3.3V: C101.1, C103.1, C104.1, C105.1, C106.2, C107.1, C110.1, C113.1, C115.1, C116.1, C117.1, C118.1, C120.1, C121.1, D101.2 (A), D102.2 (A), D103.2 (A), D104.2 (A), D105.2 (A), D106.2 (A), D107.2 (A), D108.2 (A), IC101.14 (VBATT), IC101.21 (VCC_1), IC101.40 (VCC_USB), IC101.48 (VCC_2), IC101.68 (VCC_3), IC101.78 (VCC_4), IC101.86 (VCC_5), IC101.88 (VCC_DCDC_1), IC101.89 (VCC_DCDC_2), IC101.106 (VCC2), IC101.117 (VCC_6), IC101.139 (VCC_7), J102.1, J104.1, J106.1, J107.1, J109.22, J110.4 (VDD), LED101.1 (COMMON_ANODE), LED102.1 (COMMON_ANODE), R106.1, R108.1, R121.1, R124.1, R131.2, R132.2, R133.2, R134.2, R135.2, R136.2, RV101.1, RV102.1, U101.5 (VDD), U101.9 (XRSETB), Y101.1 (INH), Y101.4 (VCC); also elsewhere on the board
+5V: C119.2, D117.1 (K), J101.1, R125.1; also elsewhere on the board
/EXTAL: IC101.20 (P212/EXTAL), Y101.3 (OUTPUT)
/MD: IC101.55 (P201/MD), SW107.2 (B)
/P000_FL_CS: IC101.137 (P000), J109.4
/P001_FR_CS: IC101.136 (P001), J109.3
/P002_RL_CS: IC101.135 (P002), J109.2
/P003_RR_CS: IC101.134 (P003), J109.1
/P004_TSL_OUT: IC101.133 (P004), J104.3
/P102_FL_PWM: IC101.104 (P102), J109.15
/P103_FR_PWM: IC101.103, J109.12
/P104_RL_PWM: IC101.102 (P104), J109.11
/P105_RR_PWM: IC101.101 (P105), J109.8
/P106_ST_SR: IC101.100 (P106), J109.19
/P107_FL_SR: IC101.99 (P107), J109.16
/P112_ST_PWM: IC101.73 (P112), J109.18
/P113_SPI0_CS1: IC101.74 (P113)
/P114_SPI0_CS0: IC101.75 (P114), J106.6
/P115_SPI0_MOSI: IC101.76 (P115), J106.5
/P203_LED15: IC101.44 (P203)
/P204_LED14: IC101.43 (P204)
/P205_LED13: IC101.42 (P205)
/P206_LED12: IC101.41 (P206)
/P208_JTAG_TDI: IC101.53 (P208/TDI), J102.8
/P209_JTAG_TDO: IC101.52 (P209/TDO), J102.6
/P210_JTAG_TMS: IC101.51 (P210/TMS/SWDIO), J102.2
/P211_JTAG_TCK: IC101.50 (P211/TCK/SWCLK), J102.4, R124.2, SW107.1 (C)
/P300_RR_PHASE: IC101.72 (P300), J109.6
/P301_SD_DAT3: IC101.71 (P301), J110.2 (CD/DAT3), R134.1
/P302_SD_DAT2: IC101.70 (P302), J110.1 (DAT2), R133.1
/P303_SD_DAT1: IC101.69 (P303), J110.8 (DAT1), R132.1
/P304_SD_DAT0: IC101.66 (P304), J110.7 (DAT0), R131.1
/P306_SD_CD: IC101.64 (P306), J110.SWA (A), R136.1
/P307_SD_CMD: IC101.63 (P307), J110.3 (CMD), R135.1
/P308_SD_CLK: IC101.62 (P308), J110.5 (CLK)
/P400_SCL: IC101.1 (P400), J107.4, R108.2, U101.8 (SCL)
/P401_SDA: IC101.2 (P401), J107.3, R106.2, U101.7 (SDA)
/P402_DIP1_1: IC101.3 (P402), S101.2 (NO_1)
/P403_DIP1_2: IC101.4 (P403), S101.4 (NO_2)
/P404_DIP1_4: IC101.5 (P404), S101.6 (NO_3)
/P405_DIP1_8: IC101.6 (P405), S101.8 (NO_4)
/P407_USB_VBUS: IC101.36 (P407), R125.2
/P408_LED11: IC101.35 (P408)
/P409_LED10: IC101.34 (P409)
/P410_LED9: IC101.33 (P410)
/P411_LED8: IC101.32 (P411)
/P412_LED7: IC101.31 (P412), R110.2
/P413_LED6: IC101.30 (P413), R109.2
/P414_ENC_A: IC101.29 (P414), J101.3
/P415_ENC_B: IC101.28 (P415), J101.4
/P511_TSL_SI: IC101.144 (P511), J104.5
/P512_TSL_CLK: IC101.143 (P512), J104.4
/P513_VR_PIN1: IC101.142 (P513), RV101.2
/P600_FR_SR: IC101.98 (P600), J109.13
/P601_RL_SR: IC101.97 (P601), J109.10
/P602_RR_SR: IC101.96 (P602), J109.7
/P609_SPI0_MISO: IC101.77 (P609), J106.4
/P610_SPI0_SCK: IC101.80 (P610), J106.3
/P611_RL_PHASE: IC101.81 (P611), J109.9
/P612_FR_PHASE: IC101.82 (P612), J109.14
/P613_FL_PHASE: IC101.83 (P613), J109.17
/P614_ST_PHASE: IC101.84 (P614), J109.20
/P700_FLED1_R: IC101.8 (P700), R123.1
/P701_FLED1_G: IC101.9 (P701), R120.1
/P702_FLED1_B: IC101.10 (P702), R129.1
/P703_FLED2_R: IC101.11 (P703), R122.1
/P704_FLED2_G: IC101.12 (P704), R119.1
/P705_FLED2_B: IC101.13 (P705), R128.1
/P708_LED5: IC101.27 (P708), R107.2
/P709_LED4: IC101.26 (P709), R105.2
/P710_LED3: IC101.25 (P710), R104.2
/P711_LED2: IC101.24 (P711), R103.2
/P712_LED1: IC101.23 (P712), R102.2
/P713_LED0: IC101.22 (P713), R101.2
/P801_TSW_SELECT2: IC101.110 (P801), SW106.2
/P802_TSW_SELECT1: IC101.111 (P802), SW105.2
/P803_TSW_RIGHT: IC101.112 (P803)
/P804_TSW_LEFT: IC101.113 (P804)
/P805_VR_ST: IC101.141 (P805), RV102.2
/P806_ST_CS: IC101.140 (P806), J109.5
/P808_TSW_DOWN: IC101.114 (P808), SW103.2
/P809_TSW_UP: IC101.115 (P809), SW102.2
/P814_USB_DP: IC101.39 (P814/USB_DP), J103.A6 (D+), J103.B6 (D+)
/P815_USB_DM: IC101.38 (P815/USB_DM), J103.A7 (D-), J103.B7 (D-)
/RESET: IC101.54 (RES), J102.10, R121.2, SW108.2
/VCL_1: C102.1, C108.1, C111.1, C112.1, C114.1, IC101.15 (VCL_1), IC101.49 (VCL_2), IC101.87 (VCL_3), IC101.116 (VCL_4), L101.2
/VLO: IC101.90 (VLO_1), IC101.91 (VLO_2), L101.1
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C107.2, C108.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.1, C120.2, C121.2, IC101.18 (VSS_1), IC101.37 (VSS_USB), IC101.47 (VSS_2), IC101.67 (VSS_3), IC101.79 (VSS_4), IC101.85 (VSS_5), IC101.92 (VSS_DCDC), IC101.107 (VSS_6), IC101.118 (VSS_7), IC101.138 (VSS_8), J101.2, J102.3, J102.5, J102.9, J103.A1 (GND), J103.A12 (GND), J103.B1 (GND), J103.B12 (GND), J103.S1 (SHIELD), J104.2, J106.2, J107.2, J109.21, J110.6 (VSS), J110.P1 (SHIELD), J110.P2 (SHIELD__1), J110.P3 (SHIELD__2), J110.P4 (SHIELD__3), J110.SWB (B), R126.2, R127.2, R137.1, RV101.3, RV102.3, S101.1 (COM_), S101.3 (COM_1), S101.5 (COM_2), S101.7 (COM_3), SW102.3, SW103.3, SW105.3, SW106.3, SW107.3 (A), SW108.3, U101.6 (VSS), Y101.2 (CASE_GND); also elsewhere on the board
unnamed: D101.1 (K), R101.1
unnamed: D102.1 (K), R102.1
unnamed: D103.1 (K), R103.1
unnamed: D104.1 (K), R104.1
unnamed: D105.1 (K), R105.1
unnamed: D106.1 (K), R107.1
unnamed: D107.1 (K), R109.1
unnamed: D108.1 (K), R110.1
unnamed: D117.2 (A), J103.A4 (VBUS), J103.A9 (VBUS), J103.B4 (VBUS), J103.B9 (VBUS)
unnamed: IC101.122 (VREFH), IC101.123 (AVCC0), IC101.126 (VREFH0)
unnamed: IC101.121 (VREFL), IC101.124 (AVSS0), IC101.125 (VREFL0)
unnamed: IC101.16 (XCIN), R137.2
unnamed: J103.A5 (CC1), R127.1
unnamed: J103.B5 (CC2), R126.1
unnamed: LED101.4 (CATHODE_BLUE), R128.2
unnamed: LED101.3 (CATHODE_GREEN), R119.2
unnamed: LED101.2 (CATHODE_RED), R122.2
unnamed: LED102.4 (CATHODE_BLUE), R129.2
unnamed: LED102.3 (CATHODE_GREEN), R120.2
unnamed: LED102.2 (CATHODE_RED), R123.2
unnamed: C109.2, U101.3 (CAP1N)
unnamed: C109.1, U101.4 (CAP1P)
unnamed: C106.1, U101.2 (VOUT)

Notes on the sheet:
スイッチ系
ST_potentio
エンコーダー
USB
JTAG
motorConn
SPI
TSL1401
IMU_SPI
LED系
SDカード
AQM0802A-RN-GBW
クロック
I2C
LCD
電源系
IMU_I2C

Parts:
C201: 100u; CP_Elec_6.3x5.9
C202: 0.1u; C_0603_1608Metric
C203: 5600p; C_0603_1608Metric
C204: 2.2u; C_0603_1608Metric
C205, C206: 4.7u; C_0805_2012Metric
C207: 1u; C_0805_2012Metric
D201, D202: D; D_SMA
D203: 1.5KExxA; D_A-405_P10.16mm_Horizontal
IC201: MAXM17634AMG+T; MAXM17634AMGT; Mouser Part Number 700-MAXM17634AMG+T
J201: Conn_01x02_Pin; AMASS_XT30UPB-M_1x02_P5.0mm_Vertical
R201: 19.1k; R_0603_1608Metric
R202: 100k; R_0603_1608Metric
U201: LDL1117S33R; SOT230P700X180-4N; PARTREV 7

Connections:
+3.3V: C206.1, D202.2 (A), U201.2 (VOUT), U201.4 (VOUT__1); also elsewhere on the board
+5V: C207.1, D201.2 (A), D202.1 (K), IC201.3 (EXTVCC), IC201.4 (OUT_1), IC201.5 (OUT_2), IC201.6 (OUT_3), IC201.7 (OUT_4), IC201.8 (FB), U201.3 (VIN); also elsewhere on the board
+12V: C201.1, C205.1, D201.1 (K), D203.1 (A1), IC201.15 (EV/UVLO), IC201.16 (IN_1), IC201.17 (IN_2), IC201.18 (IN_3), IC201.19 (IN_4), J201.2
GND: C201.2, C202.1, C203.2, C204.2, C205.2, C206.2, C207.2, D203.2 (A2), IC201.1 (LX_1), IC201.10 (SGND), IC201.20 (PGND_1), IC201.21 (PGND_2), IC201.22 (PGND_3), IC201.23 (PGND_4), IC201.24 (LX_2), IC201.25 (PGND_5), J201.1, R201.2, U201.1 (GND); also elsewhere on the board
unnamed: C202.2, IC201.2 (BST)
unnamed: IC201.9 (RT), R201.1
unnamed: C203.1, IC201.11 (SS)
unnamed: C204.1, IC201.13 (VCC), R202.2
unnamed: IC201.14 (~RESET), R202.1

Board: 4 copper layers, 60.0 x 75.0 mm, 96 parts (21 on the bottom side), 106 nets.

## Commit log

2025-12-12 こみこみーーー
2025-12-14 おんぎゃ
2025-12-15 うぎゃああああああああああ
2025-12-18 おおおおおおお
2025-12-18 おおおおおおおおお
2025-12-22 配線微調整
